# Keil uVision project WiFi_Ctrl_103C8.uvprojx, settings and files
target WiFi_Ctrl (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WiFi_Ctrl
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,_DEBUG
  c misc: --diag_suppress=177 --diag_suppress=550
  c include: ..\HAL\Inc;..\HAL\Drivers/STM32F1xx_HAL_Driver/Inc;..\HAL\Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\HAL\Drivers/CMSIS/Include;..\HAL\Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Source
    ../Source/: main.c html.c esp8266.c http.c control.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c
  group Application/User
    ../Src/: gpio.c dma.c stm32f1xx_hal_msp.c usart.c stm32f1xx_it.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 4.1.0
