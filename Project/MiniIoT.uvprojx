# Keil uVision project MiniIoT.uvprojx, settings and files
target MiniIoT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MiniIoT
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,_DEBUG
  c misc: --diag_suppress=177 --diag_suppress=550
  c include: ..\HAL\Inc;..\HAL\Drivers/STM32F1xx_HAL_Driver/Inc;..\HAL\Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\HAL\Drivers/CMSIS/Include;..\HAL\Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Source
    ../Source/: main.c html.c esp8266.c http.c control.c
  group Application/User
    ../HAL/Src/: dma.c gpio.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../HAL/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../HAL/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/MDK-ARM
    ../HAL/MDK-ARM/: startup_stm32f103xb.s
software components: CMSIS:CORE 4.1.0
